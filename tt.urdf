Commit message: requirements & license

File: tt.urdf (robot description, URDF)
Before this commit: robot SImple, 17 links, 16 joints
Joints:
- joint Revolute_BR_Knee: axis -0.0 0.0 -1.0 -> -0.0 0.0 1.0
